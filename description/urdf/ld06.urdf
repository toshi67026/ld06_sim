Commit message: fix models

File: description/urdf/ld06.urdf (robot description, URDF)
Before this commit: robot ld06, 2 links, 1 joints
Links:
- link base_link: geometry collision box size=0.039 0.039 0.0333; visual mesh filename=package://ld06_sim/description/meshes/ld06.stl
